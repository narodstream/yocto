FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://gpio-fragment.cfg"
SRC_URI += "file://aux-fragment.cfg"
